

# LEF File for Accumulated Process Antenna Effects at the Boundary Pins
# *********************************************************************

VERSION 5.5 ;
NAMESCASESENSITIVE ON ;
DIVIDERCHAR "/" ;
BUSBITCHARS "[]" ;

MACRO chip 
  PIN clk 
    ANTENNAPARTIALCUTAREA 0.0324 LAYER Via9 ;
    ANTENNAPARTIALMETALAREA 0.1008 LAYER Metal10 ;
    ANTENNAPARTIALMETALSIDEAREA 1.32 LAYER Metal10 ;
    ANTENNAPARTIALCUTAREA 0.0324 LAYER Via10 ;
    ANTENNAPARTIALMETALAREA 5.68 LAYER Metal11 ;
    ANTENNAPARTIALMETALSIDEAREA 10.84 LAYER Metal11 ;
  END clk
  PIN rst_b 
    ANTENNAPARTIALCUTAREA 0.0324 LAYER Via9 ;
    ANTENNAPARTIALMETALAREA 0.1008 LAYER Metal10 ;
    ANTENNAPARTIALMETALSIDEAREA 1.32 LAYER Metal10 ;
    ANTENNAPARTIALCUTAREA 0.0324 LAYER Via10 ;
    ANTENNAPARTIALMETALAREA 5.68 LAYER Metal11 ;
    ANTENNAPARTIALMETALSIDEAREA 10.84 LAYER Metal11 ;
  END rst_b
  PIN op_a[7] 
    ANTENNAPARTIALCUTAREA 0.0324 LAYER Via9 ;
    ANTENNAPARTIALMETALAREA 0.1008 LAYER Metal10 ;
    ANTENNAPARTIALMETALSIDEAREA 1.32 LAYER Metal10 ;
    ANTENNAPARTIALCUTAREA 0.0324 LAYER Via10 ;
    ANTENNAPARTIALMETALAREA 5.68 LAYER Metal11 ;
    ANTENNAPARTIALMETALSIDEAREA 10.84 LAYER Metal11 ;
  END op_a[7]
  PIN op_a[6] 
    ANTENNAPARTIALMETALAREA 0.0013 LAYER Metal9 ;
    ANTENNAPARTIALMETALSIDEAREA 0.01 LAYER Metal9 ;
    ANTENNAPARTIALCUTAREA 0.0324 LAYER Via9 ;
    ANTENNAPARTIALMETALAREA 0.1008 LAYER Metal10 ;
    ANTENNAPARTIALMETALSIDEAREA 1.32 LAYER Metal10 ;
    ANTENNAPARTIALCUTAREA 0.0324 LAYER Via10 ;
    ANTENNAPARTIALMETALAREA 5.68 LAYER Metal11 ;
    ANTENNAPARTIALMETALSIDEAREA 10.84 LAYER Metal11 ;
  END op_a[6]
  PIN op_a[5] 
    ANTENNAPARTIALCUTAREA 0.0324 LAYER Via9 ;
    ANTENNAPARTIALMETALAREA 0.1008 LAYER Metal10 ;
    ANTENNAPARTIALMETALSIDEAREA 1.32 LAYER Metal10 ;
    ANTENNAPARTIALCUTAREA 0.0324 LAYER Via10 ;
    ANTENNAPARTIALMETALAREA 5.68 LAYER Metal11 ;
    ANTENNAPARTIALMETALSIDEAREA 10.84 LAYER Metal11 ;
  END op_a[5]
  PIN op_a[4] 
    ANTENNAPARTIALCUTAREA 0.0324 LAYER Via9 ;
    ANTENNAPARTIALMETALAREA 0.1008 LAYER Metal10 ;
    ANTENNAPARTIALMETALSIDEAREA 1.32 LAYER Metal10 ;
    ANTENNAPARTIALCUTAREA 0.0324 LAYER Via10 ;
    ANTENNAPARTIALMETALAREA 5.68 LAYER Metal11 ;
    ANTENNAPARTIALMETALSIDEAREA 10.84 LAYER Metal11 ;
  END op_a[4]
  PIN op_a[3] 
    ANTENNAPARTIALMETALAREA 0.0026 LAYER Metal9 ;
    ANTENNAPARTIALMETALSIDEAREA 0.02 LAYER Metal9 ;
    ANTENNAPARTIALCUTAREA 0.0324 LAYER Via9 ;
    ANTENNAPARTIALMETALAREA 0.1008 LAYER Metal10 ;
    ANTENNAPARTIALMETALSIDEAREA 1.32 LAYER Metal10 ;
    ANTENNAPARTIALCUTAREA 0.0324 LAYER Via10 ;
    ANTENNAPARTIALMETALAREA 5.68 LAYER Metal11 ;
    ANTENNAPARTIALMETALSIDEAREA 10.84 LAYER Metal11 ;
  END op_a[3]
  PIN op_a[2] 
    ANTENNAPARTIALCUTAREA 0.0324 LAYER Via9 ;
    ANTENNAPARTIALMETALAREA 0.1008 LAYER Metal10 ;
    ANTENNAPARTIALMETALSIDEAREA 1.32 LAYER Metal10 ;
    ANTENNAPARTIALCUTAREA 0.0324 LAYER Via10 ;
    ANTENNAPARTIALMETALAREA 5.68 LAYER Metal11 ;
    ANTENNAPARTIALMETALSIDEAREA 10.84 LAYER Metal11 ;
  END op_a[2]
  PIN op_a[1] 
    ANTENNAPARTIALCUTAREA 0.0324 LAYER Via9 ;
    ANTENNAPARTIALMETALAREA 0.1008 LAYER Metal10 ;
    ANTENNAPARTIALMETALSIDEAREA 1.32 LAYER Metal10 ;
    ANTENNAPARTIALCUTAREA 0.0324 LAYER Via10 ;
    ANTENNAPARTIALMETALAREA 5.68 LAYER Metal11 ;
    ANTENNAPARTIALMETALSIDEAREA 10.84 LAYER Metal11 ;
  END op_a[1]
  PIN op_a[0] 
    ANTENNAPARTIALMETALAREA 0.0039 LAYER Metal9 ;
    ANTENNAPARTIALMETALSIDEAREA 0.03 LAYER Metal9 ;
    ANTENNAPARTIALCUTAREA 0.0324 LAYER Via9 ;
    ANTENNAPARTIALMETALAREA 0.1008 LAYER Metal10 ;
    ANTENNAPARTIALMETALSIDEAREA 1.32 LAYER Metal10 ;
    ANTENNAPARTIALCUTAREA 0.0324 LAYER Via10 ;
    ANTENNAPARTIALMETALAREA 5.68 LAYER Metal11 ;
    ANTENNAPARTIALMETALSIDEAREA 10.84 LAYER Metal11 ;
  END op_a[0]
  PIN op_b[7] 
    ANTENNAPARTIALCUTAREA 0.0324 LAYER Via9 ;
    ANTENNAPARTIALMETALAREA 0.1008 LAYER Metal10 ;
    ANTENNAPARTIALMETALSIDEAREA 1.32 LAYER Metal10 ;
    ANTENNAPARTIALCUTAREA 0.0324 LAYER Via10 ;
    ANTENNAPARTIALMETALAREA 5.68 LAYER Metal11 ;
    ANTENNAPARTIALMETALSIDEAREA 10.84 LAYER Metal11 ;
  END op_b[7]
  PIN op_b[6] 
    ANTENNAPARTIALMETALAREA 0.0013 LAYER Metal9 ;
    ANTENNAPARTIALMETALSIDEAREA 0.01 LAYER Metal9 ;
    ANTENNAPARTIALCUTAREA 0.0324 LAYER Via9 ;
    ANTENNAPARTIALMETALAREA 0.1008 LAYER Metal10 ;
    ANTENNAPARTIALMETALSIDEAREA 1.32 LAYER Metal10 ;
    ANTENNAPARTIALCUTAREA 0.0324 LAYER Via10 ;
    ANTENNAPARTIALMETALAREA 5.68 LAYER Metal11 ;
    ANTENNAPARTIALMETALSIDEAREA 10.84 LAYER Metal11 ;
  END op_b[6]
  PIN op_b[5] 
    ANTENNAPARTIALCUTAREA 0.0324 LAYER Via9 ;
    ANTENNAPARTIALMETALAREA 0.1008 LAYER Metal10 ;
    ANTENNAPARTIALMETALSIDEAREA 1.32 LAYER Metal10 ;
    ANTENNAPARTIALCUTAREA 0.0324 LAYER Via10 ;
    ANTENNAPARTIALMETALAREA 5.68 LAYER Metal11 ;
    ANTENNAPARTIALMETALSIDEAREA 10.84 LAYER Metal11 ;
  END op_b[5]
  PIN op_b[4] 
    ANTENNAPARTIALCUTAREA 0.0324 LAYER Via9 ;
    ANTENNAPARTIALMETALAREA 0.1008 LAYER Metal10 ;
    ANTENNAPARTIALMETALSIDEAREA 1.32 LAYER Metal10 ;
    ANTENNAPARTIALCUTAREA 0.0324 LAYER Via10 ;
    ANTENNAPARTIALMETALAREA 5.68 LAYER Metal11 ;
    ANTENNAPARTIALMETALSIDEAREA 10.84 LAYER Metal11 ;
  END op_b[4]
  PIN op_b[3] 
    ANTENNAPARTIALMETALAREA 0.0026 LAYER Metal9 ;
    ANTENNAPARTIALMETALSIDEAREA 0.02 LAYER Metal9 ;
    ANTENNAPARTIALCUTAREA 0.0324 LAYER Via9 ;
    ANTENNAPARTIALMETALAREA 0.1008 LAYER Metal10 ;
    ANTENNAPARTIALMETALSIDEAREA 1.32 LAYER Metal10 ;
    ANTENNAPARTIALCUTAREA 0.0324 LAYER Via10 ;
    ANTENNAPARTIALMETALAREA 5.68 LAYER Metal11 ;
    ANTENNAPARTIALMETALSIDEAREA 10.84 LAYER Metal11 ;
  END op_b[3]
  PIN op_b[2] 
    ANTENNAPARTIALCUTAREA 0.0324 LAYER Via9 ;
    ANTENNAPARTIALMETALAREA 0.1008 LAYER Metal10 ;
    ANTENNAPARTIALMETALSIDEAREA 1.32 LAYER Metal10 ;
    ANTENNAPARTIALCUTAREA 0.0324 LAYER Via10 ;
    ANTENNAPARTIALMETALAREA 5.68 LAYER Metal11 ;
    ANTENNAPARTIALMETALSIDEAREA 10.84 LAYER Metal11 ;
  END op_b[2]
  PIN op_b[1] 
    ANTENNAPARTIALCUTAREA 0.0324 LAYER Via9 ;
    ANTENNAPARTIALMETALAREA 0.1008 LAYER Metal10 ;
    ANTENNAPARTIALMETALSIDEAREA 1.32 LAYER Metal10 ;
    ANTENNAPARTIALCUTAREA 0.0324 LAYER Via10 ;
    ANTENNAPARTIALMETALAREA 5.68 LAYER Metal11 ;
    ANTENNAPARTIALMETALSIDEAREA 10.84 LAYER Metal11 ;
  END op_b[1]
  PIN op_b[0] 
    ANTENNAPARTIALMETALAREA 0.0039 LAYER Metal9 ;
    ANTENNAPARTIALMETALSIDEAREA 0.03 LAYER Metal9 ;
    ANTENNAPARTIALCUTAREA 0.0324 LAYER Via9 ;
    ANTENNAPARTIALMETALAREA 0.1008 LAYER Metal10 ;
    ANTENNAPARTIALMETALSIDEAREA 1.32 LAYER Metal10 ;
    ANTENNAPARTIALCUTAREA 0.0324 LAYER Via10 ;
    ANTENNAPARTIALMETALAREA 5.68 LAYER Metal11 ;
    ANTENNAPARTIALMETALSIDEAREA 10.84 LAYER Metal11 ;
  END op_b[0]
  PIN res[7] 
    ANTENNAPARTIALCUTAREA 0.0324 LAYER Via9 ;
    ANTENNAPARTIALMETALAREA 0.1008 LAYER Metal10 ;
    ANTENNAPARTIALMETALSIDEAREA 1.32 LAYER Metal10 ;
    ANTENNAPARTIALCUTAREA 0.0324 LAYER Via10 ;
    ANTENNAPARTIALMETALAREA 11.26 LAYER Metal11 ;
    ANTENNAPARTIALMETALSIDEAREA 13.63 LAYER Metal11 ;
  END res[7]
  PIN res[6] 
    ANTENNAPARTIALCUTAREA 0.0324 LAYER Via9 ;
    ANTENNAPARTIALMETALAREA 0.1008 LAYER Metal10 ;
    ANTENNAPARTIALMETALSIDEAREA 1.32 LAYER Metal10 ;
    ANTENNAPARTIALCUTAREA 0.0324 LAYER Via10 ;
    ANTENNAPARTIALMETALAREA 11.26 LAYER Metal11 ;
    ANTENNAPARTIALMETALSIDEAREA 13.63 LAYER Metal11 ;
  END res[6]
  PIN res[5] 
    ANTENNAPARTIALMETALAREA 0.00525 LAYER Metal9 ;
    ANTENNAPARTIALMETALSIDEAREA 0.05 LAYER Metal9 ;
    ANTENNAPARTIALCUTAREA 0.0324 LAYER Via9 ;
    ANTENNAPARTIALMETALAREA 0.1008 LAYER Metal10 ;
    ANTENNAPARTIALMETALSIDEAREA 1.32 LAYER Metal10 ;
    ANTENNAPARTIALCUTAREA 0.0324 LAYER Via10 ;
    ANTENNAPARTIALMETALAREA 11.26 LAYER Metal11 ;
    ANTENNAPARTIALMETALSIDEAREA 13.63 LAYER Metal11 ;
  END res[5]
  PIN res[4] 
    ANTENNAPARTIALCUTAREA 0.0324 LAYER Via9 ;
    ANTENNAPARTIALMETALAREA 0.1008 LAYER Metal10 ;
    ANTENNAPARTIALMETALSIDEAREA 1.32 LAYER Metal10 ;
    ANTENNAPARTIALCUTAREA 0.0324 LAYER Via10 ;
    ANTENNAPARTIALMETALAREA 11.26 LAYER Metal11 ;
    ANTENNAPARTIALMETALSIDEAREA 13.63 LAYER Metal11 ;
  END res[4]
  PIN res[3] 
    ANTENNAPARTIALCUTAREA 0.0324 LAYER Via9 ;
    ANTENNAPARTIALMETALAREA 0.1008 LAYER Metal10 ;
    ANTENNAPARTIALMETALSIDEAREA 1.32 LAYER Metal10 ;
    ANTENNAPARTIALCUTAREA 0.0324 LAYER Via10 ;
    ANTENNAPARTIALMETALAREA 11.26 LAYER Metal11 ;
    ANTENNAPARTIALMETALSIDEAREA 13.63 LAYER Metal11 ;
  END res[3]
  PIN res[2] 
    ANTENNAPARTIALCUTAREA 0.0324 LAYER Via9 ;
    ANTENNAPARTIALMETALAREA 0.1008 LAYER Metal10 ;
    ANTENNAPARTIALMETALSIDEAREA 1.32 LAYER Metal10 ;
    ANTENNAPARTIALCUTAREA 0.0324 LAYER Via10 ;
    ANTENNAPARTIALMETALAREA 11.26 LAYER Metal11 ;
    ANTENNAPARTIALMETALSIDEAREA 13.63 LAYER Metal11 ;
  END res[2]
  PIN res[1] 
    ANTENNAPARTIALCUTAREA 0.0324 LAYER Via9 ;
    ANTENNAPARTIALMETALAREA 0.1008 LAYER Metal10 ;
    ANTENNAPARTIALMETALSIDEAREA 1.32 LAYER Metal10 ;
    ANTENNAPARTIALCUTAREA 0.0324 LAYER Via10 ;
    ANTENNAPARTIALMETALAREA 11.26 LAYER Metal11 ;
    ANTENNAPARTIALMETALSIDEAREA 13.63 LAYER Metal11 ;
  END res[1]
  PIN res[0] 
    ANTENNAPARTIALCUTAREA 0.0324 LAYER Via9 ;
    ANTENNAPARTIALMETALAREA 0.1008 LAYER Metal10 ;
    ANTENNAPARTIALMETALSIDEAREA 1.32 LAYER Metal10 ;
    ANTENNAPARTIALCUTAREA 0.0324 LAYER Via10 ;
    ANTENNAPARTIALMETALAREA 11.26 LAYER Metal11 ;
    ANTENNAPARTIALMETALSIDEAREA 13.63 LAYER Metal11 ;
  END res[0]
  PIN ops_val 
    ANTENNAPARTIALCUTAREA 0.0324 LAYER Via9 ;
    ANTENNAPARTIALMETALAREA 0.1008 LAYER Metal10 ;
    ANTENNAPARTIALMETALSIDEAREA 1.32 LAYER Metal10 ;
    ANTENNAPARTIALCUTAREA 0.0324 LAYER Via10 ;
    ANTENNAPARTIALMETALAREA 5.68 LAYER Metal11 ;
    ANTENNAPARTIALMETALSIDEAREA 10.84 LAYER Metal11 ;
  END ops_val
  PIN ops_rdy 
    ANTENNAPARTIALMETALAREA 0.0063 LAYER Metal9 ;
    ANTENNAPARTIALMETALSIDEAREA 0.06 LAYER Metal9 ;
    ANTENNAPARTIALCUTAREA 0.0324 LAYER Via9 ;
    ANTENNAPARTIALMETALAREA 0.1008 LAYER Metal10 ;
    ANTENNAPARTIALMETALSIDEAREA 1.32 LAYER Metal10 ;
    ANTENNAPARTIALCUTAREA 0.0324 LAYER Via10 ;
    ANTENNAPARTIALMETALAREA 11.26 LAYER Metal11 ;
    ANTENNAPARTIALMETALSIDEAREA 13.63 LAYER Metal11 ;
  END ops_rdy
  PIN res_rdy 
    ANTENNAPARTIALCUTAREA 0.0324 LAYER Via9 ;
    ANTENNAPARTIALMETALAREA 0.1008 LAYER Metal10 ;
    ANTENNAPARTIALMETALSIDEAREA 1.32 LAYER Metal10 ;
    ANTENNAPARTIALCUTAREA 0.0324 LAYER Via10 ;
    ANTENNAPARTIALMETALAREA 5.68 LAYER Metal11 ;
    ANTENNAPARTIALMETALSIDEAREA 10.84 LAYER Metal11 ;
  END res_rdy
  PIN res_val 
    ANTENNAPARTIALMETALAREA 0.0063 LAYER Metal9 ;
    ANTENNAPARTIALMETALSIDEAREA 0.06 LAYER Metal9 ;
    ANTENNAPARTIALCUTAREA 0.0324 LAYER Via9 ;
    ANTENNAPARTIALMETALAREA 0.1008 LAYER Metal10 ;
    ANTENNAPARTIALMETALSIDEAREA 1.32 LAYER Metal10 ;
    ANTENNAPARTIALCUTAREA 0.0324 LAYER Via10 ;
    ANTENNAPARTIALMETALAREA 11.26 LAYER Metal11 ;
    ANTENNAPARTIALMETALSIDEAREA 13.63 LAYER Metal11 ;
  END res_val
END chip

END LIBRARY
